export PSCI_DISABLE_BIGLITTLE_IN_CA57BOOT="0"
